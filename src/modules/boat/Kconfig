## src/modules/boat/Kconfig
```kconfig
menuconfig MODULES_BOAT
	bool "boat"
	default n
	---help---
		Enable support for boats
```
